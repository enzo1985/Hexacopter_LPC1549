# Keil uVision project template.uvproj, settings and files
target rt-thread_lpc15xx (ARM-ADS)
  device: LPC1549 NXP
  cpu: IRAM(0x02000000-0x02008FFF) IROM(0x0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc15xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x9000
